# Keil uVision project Huawei_LiteOS.uvprojx, settings and files
target HuaweiLiteOS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Huawei_LiteOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\example\include;..\..\kernel\base\include;..\..\kernel\include;..\..\kernel\link\keil;..\..\kernel\config;..\..\kernel\cpu\arm\cortex-m7;..\..\kernel\cmsis;..\..\platform\STM32F746ZG_NUCLEO;..\..\user;..\..\BSP\STM32F7xx\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\..\BSP\STM32F7xx\Drivers\STM32F7xx_HAL_Driver\Inc;..\..\BSP\STM32F7xx\Drivers\BSP\STM32F7xx_Nucleo_144;..\..\BSP\STM32F7xx\Drivers\BSP\Components\Common;..\..\BSP\STM32F7xx\Inc;..\..\BSP\STM32F7xx\Src;..\..\BSP\STM32F7xx\Drivers\CMSIS\Include;..\..\kernel\net\LwIP\src\include;..\..\kernel\net\LwIP\system;..\..\IotTP\json\cJSON-1.4.5;..\..\IotTP\microcoap;..\..\oceanagent
  library: MicroLIB
  memory RVCT4: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group kernel
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
  group cpu/m7
    ../../kernel/cpu/arm/cortex-m7/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch_keil.s
  group config
    ../../kernel/config/: los_config.c
  group cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
  group platform/stm32f746zg
    ../../platform/STM32F746ZG_NUCLEO/: los_bsp_adapter.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c
  group example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
  group startup
    ../../platform/STM32F746ZG_NUCLEO/: los_startup_keil.s
  group user
    ../../user/: main.c
